Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], ExchangeRequirement [Architecture]
File name: F_2023_...
Time: 2022-12-12T11:02:32+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.20.21 - Exporter 23.1.1.0 - Alternative Benutzeroberfläche 23.1.1.0

# IfcProject, F_2023_...
LongName: Projektname

# IfcSite, Default
RefLatitude: 47, 22, 8, 480529; RefLongitude: 8, 32, 16, 917114; RefElevation: 0 mm
Pset_SiteCommon - Reference: Projektinformationen

# IfcBuilding
Pset_BuildingCommon - Reference: Projektinformationen; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Projektinformationen; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Projektinformationen; sets with these values: 2

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
LongName: Ebene 0; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Ebene

# IfcElectricAppliance: GSM5 Star:GMS5 Star, GSM5 Star:GMS5 Star:2834898
In: Ebene 0
Type - Material: QF_Paint-Grey-Dark, QF_Metal-Stainless, QF_Paint-Turquoise
Type - Pset_ManufacturerTypeInformation - Manufacturer: Brunner Anliker
Pset_ElectricApplianceTypeCommon - Reference: GMS5 Star; sets with these values: 2
