Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement [Architecture]
File name: F_2023_...
Time: 2022-12-12T11:01:09+01:00
Written by: ODA SDAI 22.12
Made in: 23.0.20.21 - Exporter 23.1.1.0 - Alternative Benutzeroberfläche 23.1.1.0

# IfcProject, F_2023_...
LongName: Projektname

# IfcSite, Default
RefLatitude: 47, 22, 8, 480529; RefLongitude: 8, 32, 16, 917114; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Ebene:Ebene, Ebene 0
LongName: Ebene 0; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Ebene 0; sets with these values: 2

# IfcFlowTerminal: GSM5 Star:GMS5 Star, GSM5 Star:GMS5 Star:2834898
In: Ebene 0
Type - Material: QF_Paint-Grey-Dark (6), QF_Metal-Stainless (4), QF_Paint-Turquoise
Type - Pset_ManufacturerTypeInformation - Manufacturer: Brunner Anliker
Pset_DistributionFlowElementCommon - Reference: GMS5 Star; sets with these values: 2
